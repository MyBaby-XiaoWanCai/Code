# Keil uVision project JN910_HwVersionC_V1.0.uvprojx, settings and files
target JN910_HwVersionC_V1.0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: JN910 +hex
  AfterMake: D:\WorkPlan\JN910_Project_Code\JN910_HwVersionC_V1.1\JN910_HwVersionC_V1.0\MDK-ARM\CopyBin_Flash.bat
  AfterMake: D:\WorkPlan\JN910_Project_Code\JN910_HwVersionC_V1.1\JN910_HwVersionC_V1.0\MDK-ARM\CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F429xx,NDEBUG
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\User_Bsp;..\User_Task
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c can.c dma.c iwdg.c rng.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rng.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group User_Bsp
    ../User_Bsp/: bsp_MB85RS2.c bsp_dwt.c bsp_ads131.c bsp_can.c bsp_dac80501.c bsp_fan.c bsp_temp.c bsp_rng.c bsp_charge.c bsp_i2c.c bsp_pca9555.c bsp_led.c bsp_AddrErr.c bsp_eeprom.c bsp_debug.c
  group User_Task
    ../User_Task/: Task_Start.c Task_Dcdc.c Task_Debug.c Can_Network_Driver.c Can_Network_Protocol.c Can_Network_Transplant.c Can_Network_Global.h Task_Protocol.c Task_Workstep.c Task_Protection.c AppFunc_Eeprom.c Task_Led.c
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Device:Startup 2.5.0
