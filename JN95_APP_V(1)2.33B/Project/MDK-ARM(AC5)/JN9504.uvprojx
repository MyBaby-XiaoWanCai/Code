# Keil uVision project JN9504.uvprojx, settings and files
target Application (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: JN9504 +hex
  AfterMake: CopyBin_Flash.bat
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, STM32F429xx,USE_FULL_LL_DRIVER,MB85RS2_test,AD5245_test,RUNTIME_test,FLASH_test,CAN1_test,Use_FRAM_DMA,V_MOD_SP,V_TZ_SP,W5500_RESTART_PATCH,YCJ,
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Driver\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_HAL_Driver\Inc;..\..\Libraries\STM32F4xx_HAL_Driver\Src\Legacy;..\..\User;..\..\User\bsp;..\..\User\bsp\inc;..\..\User\libapp;..\..\RL-ARM\Driver;..\..\User\Middlewares\EasyFlash\inc;..\..\User\Middlewares\EasyFlash\plugins\types\struct2json\inc;..\..\User\Middlewares\EasyFlash\plugins\types
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Libraries\CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
  group Libraries\STM32F4xx_HAL_Driver
    ../../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fmc.c stm32f4xx_hal_rng.c stm32f4xx_hal_iwdg.c
  group RL-ARM
    ../../RL-ARM/Driver/: ETH_INIT.c EMAC_STM32F4xx.c EMAC_STM32F4xx.h PHY_KSZ8041NL.c PHY_KSZ8041NL.h
  group User
    ../../User/: global.h main.c
  group System\interrupt
    ../../User/bsp/: stm32f4xx_it.c
  group User\bsp
    ../../User/bsp/: bsp.c stm32f4xx_hal_timebase.c
    ../../User/bsp/src/: bsp_demo.c bsp_eeprom.c bsp_dwt.c bsp_flash.c bsp_lan.c bsp_led.c bsp_spi.c bsp_tim_pwm.c bsp_timer.c socket.c w5500.c wizchip_conf.c bsp_gpio.c bsp_protection.c bsp_charge.c bsp_debug.c bsp_adc3.c bsp_acdc.c bsp_ad7124.c bsp_ad7175.c bsp_dac80508.c bsp_AD5245.c bsp_MB85RS2.c bsp_rng.c iwdg.c ringbuffer.c
  group User\libapp
    ../../User/libapp/: app_func_eeprom.c app_task_ageing.c app_task_eth.c app_task_led.c app_task_protection.c app_task_debug.c app_timer_Periodic_adc3.c app_task_acdc_alarm.c app_task_protocol.c app_task_workstep.c
  group User\segger
    ../../User/segger/HardFaultHandlerMDK/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group Middlewares\easy_flash
    ../../User/Middlewares/EasyFlash/port/: ef_port.c
    ../../User/Middlewares/EasyFlash/src/: easyflash.c ef_env.c ef_utils.c
software components: CMSIS:CORE 5.3.0, CMSIS:RTOS2:Keil RTX5 5.5.1, Compiler:Event Recorder 1.4.0, Network:CORE 7.14.0, Network:Interface:ETH 7.14.0, Network:Socket:TCP 7.14.0, Network:Socket:UDP 7.14.0, CMSIS Driver:Ethernet MAC 2.9, CMSIS Driver:Ethernet PHY:KSZ8081RNA 6.3.0, Device:STM32Cube Framework:Classic 1.7.9, Device:STM32Cube HAL:Common 1.7.9, Device:STM32Cube HAL:Cortex 1.7.9, Device:STM32Cube HAL:GPIO 1.7.9, Device:STM32Cube HAL:PWR 1.7.9, Device:STM32Cube HAL:RCC 1.7.9, Device:Startup 2.6.3
