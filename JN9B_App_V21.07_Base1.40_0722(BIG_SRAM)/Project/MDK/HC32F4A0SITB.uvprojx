# Keil uVision project HC32F4A0SITB.uvprojx, settings and files
target HC32F4A0SITB_Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F4A0SITB HDSC
  pack: HDSC.HC32F4A0.1.0.4
  cpu: IROM(0x00000000,0x200000) IROM2(0x03000000,0x1800) IRAM(0x1FFE0000,0x80000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: HC32F4A0SITB +hex
  AfterMake: CopyBin_Flash.bat
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __DEBUG,HC32F4A0,USE_DDL_DRIVER,V_MOD_SP
  c misc: --diag_suppress=186,66
  c include: ..\..\Libraries\driver\inc;..\..\User;..\..\User\BSP;..\..\User\w5500_sdk;..\..\User\Libapp;..\..\User\BSP\inc;..\..\User\can;..\Common
  library: MicroLIB
  memory RVCT4: ROM 0x20000 size 0x200000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1ffe0000 size 0x80000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group Common
    ../Common/: system_hc32f4a0.c startup_hc32f4a0.s
  group Libraries
    ../../Libraries/driver/src/: hc32f4a0_adc.c hc32f4a0_aes.c hc32f4a0_can.c hc32f4a0_clk.c hc32f4a0_cmp.c hc32f4a0_crc.c hc32f4a0_ctc.c hc32f4a0_dac.c hc32f4a0_dcu.c hc32f4a0_dma.c hc32f4a0_dmc.c hc32f4a0_dvp.c hc32f4a0_efm.c hc32f4a0_emb.c hc32f4a0_eth.c hc32f4a0_event_port.c hc32f4a0_fcm.c hc32f4a0_fmac.c hc32f4a0_gpio.c hc32f4a0_hash.c hc32f4a0_hrpwm.c hc32f4a0_i2c.c hc32f4a0_i2s.c hc32f4a0_icg.c hc32f4a0_keyscan.c hc32f4a0_mau.c hc32f4a0_mpu.c hc32f4a0_nfc.c hc32f4a0_ots.c hc32f4a0_pwc.c hc32f4a0_qspi.c hc32f4a0_rmu.c hc32f4a0_rtc.c hc32f4a0_sdioc.c hc32f4a0_smc.c hc32f4a0_spi.c hc32f4a0_sram.c hc32f4a0_swdt.c hc32f4a0_tmr0.c hc32f4a0_tmr2.c hc32f4a0_tmr4.c hc32f4a0_tmr6.c hc32f4a0_tmra.c hc32f4a0_trng.c hc32f4a0_usart.c hc32f4a0_utility.c hc32f4a0_wdt.c hc32f4a0_interrupts.c
  group User
    ../../User/: main.c global.h version.h
  group User\bsp
    ../../User/BSP/: bsp.c
    ../../User/BSP/src/: bsp_acdc.c bsp_AD5245.c bsp_ad7124.c bsp_ad7175.c bsp_adc3.c bsp_charge.c bsp_dac80508.c bsp_dwt.c bsp_eeprom.c bsp_exti.c bsp_lan.c bsp_led.c bsp_MB85RS2.c bsp_protection.c bsp_rng.c bsp_spi.c bsp_swdt.c bsp_systick.c bsp_timer.c ringbuffer.c bsp_i2c.c bsp_pca9555.c bsp_tmp75.c bsp_pwm.c bsp_versmana.c bsp_alarm.c bsp_gpio.c bsp_debug.c bsp_pca9548.c bsp_dac.c bsp_7606.c bsp_SGM58601.c
  group w5500
    ../../User/w5500_sdk/: w5500.c w5500socket.c wizchip_conf.c
  group can
    ../../User/can/: Can_Network_Global.h Can_Network_Driver.c Can_Network_Protocol.c Can_Network_Transplant.c
  group User\libapp
    ../../User/Libapp/: app_task_led.c app_task_eth.c app_func_eeprom.c app_task_acdc_alarm.c app_task_ageing.c app_task_debug.c app_task_protection.c app_task_protocol.c app_task_workstep.c app_timer_Periodic_adc3.c app_fct.c
  group 说明
    ../../: HC1.40版库使用说明.txt
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Device:Startup 1.0.0, Compiler:Event Recorder 1.4.0
